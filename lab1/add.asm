ORG 00H
LJMP MAIN
ADDER:
	MOV A, R2
	ADDC A, R3
	MOV R4, A
	RET

ADDER2:
	MOV A, R2
	ADDC A, R3
	MOV R4, A
	MOV 63H,R4
	JNB PSW.2,FINA
	RET
	
	
MAIN:	
	CLR C
	
	MOV 61H,#20
	MOV 60H,#125
	MOV 71H,#20
	MOV 70H,#125
	
	MOV A, #00H
	MOV R2, 61H
	MOV R3, 71H
	LCALL ADDER
	MOV 64H,R4
	MOV A, #00H
	MOV R2, 60H
	MOV R3, 70H
	LCALL ADDER2
	
	
	MOV 62H,#01H


FINA: LJMP FINA
	
END

	