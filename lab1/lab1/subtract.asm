ORG 00H
LJMP MAIN
SUBTRACT:
	MOV A, R2
	SUBB A, R3
	MOV R4, A
	RET

SUBTRACT2:
	MOV A, R2
	SUBB A, R3
	MOV R4, A
	MOV 63H,R4
	JNB PSW.2,FINA
	RET
	
	
MAIN:	
	CLR C
	
	MOV 61H,#125
	MOV 60H,#125
	MOV 71H,#130
	MOV 70H,#130
	
	MOV A, #00H
	MOV R2, 61H
	MOV R3, 71H
	LCALL SUBTRACT
	MOV 64H,R4
	MOV A, #00H
	MOV R2, 60H
	MOV R3, 70H
	LCALL SUBTRACT2
	
	
	MOV 62H,#01H


FINA: LJMP FINA
	
END

	